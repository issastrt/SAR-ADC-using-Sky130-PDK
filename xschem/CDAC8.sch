v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 8870 -910 8870 -870 {
lab=z0}
N 8630 -910 8630 -870 {
lab=z1}
N 8390 -910 8390 -870 {
lab=z2}
N 8150 -910 8150 -870 {
lab=z3}
N 7910 -910 7910 -870 {
lab=z4}
N 7670 -910 7670 -870 {
lab=z5}
N 7430 -910 7430 -870 {
lab=z6}
N 7190 -910 7190 -870 {
lab=z7}
N 8990 -610 9030 -610 {
lab=VDD}
N 8990 -810 8990 -610 {
lab=VDD}
N 8950 -810 8990 -810 {
lab=VDD}
N 8950 -790 8950 -550 {
lab=GND}
N 8950 -550 9030 -550 {
lab=GND}
N 8590 -610 8990 -610 {
lab=VDD}
N 8750 -810 8750 -610 {
lab=VDD}
N 8710 -790 8710 -550 {
lab=GND}
N 8540 -550 8950 -550 {
lab=GND}
N 8190 -610 8590 -610 {
lab=VDD}
N 8510 -810 8510 -610 {
lab=VDD}
N 8470 -810 8510 -810 {
lab=VDD}
N 7770 -610 8190 -610 {
lab=VDD}
N 8270 -810 8270 -610 {
lab=VDD}
N 8230 -810 8270 -810 {
lab=VDD}
N 7990 -810 8030 -810 {
lab=VDD}
N 8030 -810 8030 -610 {
lab=VDD}
N 7370 -610 7770 -610 {
lab=VDD}
N 7750 -810 7790 -810 {
lab=VDD}
N 7790 -810 7790 -610 {
lab=VDD}
N 7510 -810 7550 -810 {
lab=VDD}
N 7550 -810 7550 -610 {
lab=VDD}
N 7270 -810 7310 -810 {
lab=VDD}
N 7310 -810 7310 -610 {
lab=VDD}
N 7270 -790 7270 -570 {
lab=GND}
N 7270 -570 7270 -550 {
lab=GND}
N 7510 -790 7510 -550 {
lab=GND}
N 7750 -790 7750 -550 {
lab=GND}
N 7990 -790 7990 -560 {
lab=GND}
N 7990 -560 7990 -550 {
lab=GND}
N 8230 -790 8230 -550 {
lab=GND}
N 8470 -790 8470 -550 {
lab=GND}
N 8710 -810 8750 -810 {
lab=VDD}
N 7270 -550 8540 -550 {
lab=GND}
N 7310 -610 7370 -610 {
lab=VDD}
N 7110 -710 8790 -710 {
lab=VDD}
N 7110 -690 8790 -690 {
lab=GND}
N 15730 -1800 15870 -1800 {
lab=z1}
N 15730 -1860 15870 -1860 {
lab=OUT}
N 15450 -2030 15590 -2030 {
lab=z2}
N 15450 -2090 15590 -2090 {
lab=OUT}
N 15590 -2030 15730 -2030 {
lab=z2}
N 15590 -2090 15730 -2090 {
lab=OUT}
N 15730 -2030 15870 -2030 {
lab=z2}
N 15730 -2090 15870 -2090 {
lab=OUT}
N 14890 -2270 15030 -2270 {
lab=z3}
N 14890 -2330 15030 -2330 {
lab=OUT}
N 15030 -2270 15170 -2270 {
lab=z3}
N 15030 -2330 15170 -2330 {
lab=OUT}
N 15170 -2270 15310 -2270 {
lab=z3}
N 15170 -2330 15310 -2330 {
lab=OUT}
N 15310 -2270 15870 -2270 {
lab=z3}
N 15310 -2330 15870 -2330 {
lab=OUT}
N 15730 -2570 15870 -2570 {
lab=OUT}
N 15730 -2510 15870 -2510 {
lab=z4}
N 15590 -2570 15730 -2570 {
lab=OUT}
N 15590 -2510 15730 -2510 {
lab=z4}
N 15450 -2570 15590 -2570 {
lab=OUT}
N 15450 -2510 15590 -2510 {
lab=z4}
N 14890 -2570 15450 -2570 {
lab=OUT}
N 14890 -2510 15450 -2510 {
lab=z4}
N 14600 -2570 14740 -2570 {
lab=OUT}
N 14600 -2510 14740 -2510 {
lab=z4}
N 14460 -2570 14600 -2570 {
lab=OUT}
N 14460 -2510 14600 -2510 {
lab=z4}
N 14320 -2570 14460 -2570 {
lab=OUT}
N 14320 -2510 14460 -2510 {
lab=z4}
N 13760 -2570 14320 -2570 {
lab=OUT}
N 13760 -2510 14320 -2510 {
lab=z4}
N 14740 -2570 14890 -2570 {
lab=OUT}
N 14740 -2510 14890 -2510 {
lab=z4}
N 13500 -2820 13640 -2820 {
lab=OUT}
N 13500 -2760 13640 -2760 {
lab=z5}
N 13360 -2820 13500 -2820 {
lab=OUT}
N 13360 -2760 13500 -2760 {
lab=z5}
N 13220 -2820 13360 -2820 {
lab=OUT}
N 13220 -2760 13360 -2760 {
lab=z5}
N 12660 -2820 13220 -2820 {
lab=OUT}
N 12660 -2760 13220 -2760 {
lab=z5}
N 12370 -2820 12510 -2820 {
lab=OUT}
N 12370 -2760 12510 -2760 {
lab=z5}
N 12230 -2820 12370 -2820 {
lab=OUT}
N 12230 -2760 12370 -2760 {
lab=z5}
N 12090 -2820 12230 -2820 {
lab=OUT}
N 12090 -2760 12230 -2760 {
lab=z5}
N 11530 -2820 12090 -2820 {
lab=OUT}
N 11530 -2760 12090 -2760 {
lab=z5}
N 12510 -2820 12660 -2820 {
lab=OUT}
N 12510 -2760 12660 -2760 {
lab=z5}
N 15730 -2820 15870 -2820 {
lab=OUT}
N 15730 -2760 15870 -2760 {
lab=z5}
N 15590 -2820 15730 -2820 {
lab=OUT}
N 15590 -2760 15730 -2760 {
lab=z5}
N 15450 -2820 15590 -2820 {
lab=OUT}
N 15450 -2760 15590 -2760 {
lab=z5}
N 14890 -2820 15450 -2820 {
lab=OUT}
N 14890 -2760 15450 -2760 {
lab=z5}
N 14600 -2820 14740 -2820 {
lab=OUT}
N 14600 -2760 14740 -2760 {
lab=z5}
N 14460 -2820 14600 -2820 {
lab=OUT}
N 14460 -2760 14600 -2760 {
lab=z5}
N 14320 -2820 14460 -2820 {
lab=OUT}
N 14320 -2760 14460 -2760 {
lab=z5}
N 13760 -2820 14320 -2820 {
lab=OUT}
N 13760 -2760 14320 -2760 {
lab=z5}
N 14740 -2820 14890 -2820 {
lab=OUT}
N 14740 -2760 14890 -2760 {
lab=z5}
N 13640 -2820 13760 -2820 {
lab=OUT}
N 13640 -2760 13760 -2760 {
lab=z5}
N 9020 -3040 9160 -3040 {
lab=OUT}
N 9020 -2980 9160 -2980 {
lab=z6}
N 8880 -3040 9020 -3040 {
lab=OUT}
N 8880 -2980 9020 -2980 {
lab=z6}
N 8740 -3040 8880 -3040 {
lab=OUT}
N 8740 -2980 8880 -2980 {
lab=z6}
N 8180 -3040 8740 -3040 {
lab=OUT}
N 8180 -2980 8740 -2980 {
lab=z6}
N 7890 -3040 8030 -3040 {
lab=OUT}
N 7890 -2980 8030 -2980 {
lab=z6}
N 7750 -3040 7890 -3040 {
lab=OUT}
N 7750 -2980 7890 -2980 {
lab=z6}
N 7610 -3040 7750 -3040 {
lab=OUT}
N 7610 -2980 7750 -2980 {
lab=z6}
N 7050 -3040 7610 -3040 {
lab=OUT}
N 7050 -2980 7610 -2980 {
lab=z6}
N 8030 -3040 8180 -3040 {
lab=OUT}
N 8030 -2980 8180 -2980 {
lab=z6}
N 11250 -3040 11390 -3040 {
lab=OUT}
N 11250 -2980 11390 -2980 {
lab=z6}
N 11110 -3040 11250 -3040 {
lab=OUT}
N 11110 -2980 11250 -2980 {
lab=z6}
N 10970 -3040 11110 -3040 {
lab=OUT}
N 10970 -2980 11110 -2980 {
lab=z6}
N 10410 -3040 10970 -3040 {
lab=OUT}
N 10410 -2980 10970 -2980 {
lab=z6}
N 10120 -3040 10260 -3040 {
lab=OUT}
N 10120 -2980 10260 -2980 {
lab=z6}
N 9980 -3040 10120 -3040 {
lab=OUT}
N 9980 -2980 10120 -2980 {
lab=z6}
N 9840 -3040 9980 -3040 {
lab=OUT}
N 9840 -2980 9980 -2980 {
lab=z6}
N 9280 -3040 9840 -3040 {
lab=OUT}
N 9280 -2980 9840 -2980 {
lab=z6}
N 10260 -3040 10410 -3040 {
lab=OUT}
N 10260 -2980 10410 -2980 {
lab=z6}
N 9160 -3040 9280 -3040 {
lab=OUT}
N 9160 -2980 9280 -2980 {
lab=z6}
N 13500 -3040 13640 -3040 {
lab=OUT}
N 13500 -2980 13640 -2980 {
lab=z6}
N 13360 -3040 13500 -3040 {
lab=OUT}
N 13360 -2980 13500 -2980 {
lab=z6}
N 13220 -3040 13360 -3040 {
lab=OUT}
N 13220 -2980 13360 -2980 {
lab=z6}
N 12660 -3040 13220 -3040 {
lab=OUT}
N 12660 -2980 13220 -2980 {
lab=z6}
N 12370 -3040 12510 -3040 {
lab=OUT}
N 12370 -2980 12510 -2980 {
lab=z6}
N 12230 -3040 12370 -3040 {
lab=OUT}
N 12230 -2980 12370 -2980 {
lab=z6}
N 12090 -3040 12230 -3040 {
lab=OUT}
N 12090 -2980 12230 -2980 {
lab=z6}
N 11530 -3040 12090 -3040 {
lab=OUT}
N 11530 -2980 12090 -2980 {
lab=z6}
N 12510 -3040 12660 -3040 {
lab=OUT}
N 12510 -2980 12660 -2980 {
lab=z6}
N 15730 -3040 15870 -3040 {
lab=OUT}
N 15730 -2980 15870 -2980 {
lab=z6}
N 15590 -3040 15730 -3040 {
lab=OUT}
N 15590 -2980 15730 -2980 {
lab=z6}
N 15450 -3040 15590 -3040 {
lab=OUT}
N 15450 -2980 15590 -2980 {
lab=z6}
N 14890 -3040 15450 -3040 {
lab=OUT}
N 14890 -2980 15450 -2980 {
lab=z6}
N 14600 -3040 14740 -3040 {
lab=OUT}
N 14600 -2980 14740 -2980 {
lab=z6}
N 14460 -3040 14600 -3040 {
lab=OUT}
N 14460 -2980 14600 -2980 {
lab=z6}
N 14320 -3040 14460 -3040 {
lab=OUT}
N 14320 -2980 14460 -2980 {
lab=z6}
N 13760 -3040 14320 -3040 {
lab=OUT}
N 13760 -2980 14320 -2980 {
lab=z6}
N 14740 -3040 14890 -3040 {
lab=OUT}
N 14740 -2980 14890 -2980 {
lab=z6}
N 13640 -3040 13760 -3040 {
lab=OUT}
N 13640 -2980 13760 -2980 {
lab=z6}
N 11390 -3040 11530 -3040 {
lab=OUT}
N 11390 -2980 11530 -2980 {
lab=z6}
N 60 -3280 200 -3280 {
lab=OUT}
N 60 -3220 200 -3220 {
lab=z7}
N -80 -3280 60 -3280 {
lab=OUT}
N -80 -3220 60 -3220 {
lab=z7}
N -220 -3280 -80 -3280 {
lab=OUT}
N -220 -3220 -80 -3220 {
lab=z7}
N -780 -3280 -220 -3280 {
lab=OUT}
N -780 -3220 -220 -3220 {
lab=z7}
N -1070 -3280 -930 -3280 {
lab=OUT}
N -1070 -3220 -930 -3220 {
lab=z7}
N -1210 -3280 -1070 -3280 {
lab=OUT}
N -1210 -3220 -1070 -3220 {
lab=z7}
N -1350 -3280 -1210 -3280 {
lab=OUT}
N -1350 -3220 -1210 -3220 {
lab=z7}
N -1910 -3280 -1350 -3280 {
lab=OUT}
N -1910 -3220 -1350 -3220 {
lab=z7}
N -930 -3280 -780 -3280 {
lab=OUT}
N -930 -3220 -780 -3220 {
lab=z7}
N 2290 -3280 2430 -3280 {
lab=OUT}
N 2290 -3220 2430 -3220 {
lab=z7}
N 2150 -3280 2290 -3280 {
lab=OUT}
N 2150 -3220 2290 -3220 {
lab=z7}
N 2010 -3280 2150 -3280 {
lab=OUT}
N 2010 -3220 2150 -3220 {
lab=z7}
N 1450 -3280 2010 -3280 {
lab=OUT}
N 1450 -3220 2010 -3220 {
lab=z7}
N 1160 -3280 1300 -3280 {
lab=OUT}
N 1160 -3220 1300 -3220 {
lab=z7}
N 1020 -3280 1160 -3280 {
lab=OUT}
N 1020 -3220 1160 -3220 {
lab=z7}
N 880 -3280 1020 -3280 {
lab=OUT}
N 880 -3220 1020 -3220 {
lab=z7}
N 320 -3280 880 -3280 {
lab=OUT}
N 320 -3220 880 -3220 {
lab=z7}
N 1300 -3280 1450 -3280 {
lab=OUT}
N 1300 -3220 1450 -3220 {
lab=z7}
N 200 -3280 320 -3280 {
lab=OUT}
N 200 -3220 320 -3220 {
lab=z7}
N 4540 -3280 4680 -3280 {
lab=OUT}
N 4540 -3220 4680 -3220 {
lab=z7}
N 4400 -3280 4540 -3280 {
lab=OUT}
N 4400 -3220 4540 -3220 {
lab=z7}
N 4260 -3280 4400 -3280 {
lab=OUT}
N 4260 -3220 4400 -3220 {
lab=z7}
N 3700 -3280 4260 -3280 {
lab=OUT}
N 3700 -3220 4260 -3220 {
lab=z7}
N 3410 -3280 3550 -3280 {
lab=OUT}
N 3410 -3220 3550 -3220 {
lab=z7}
N 3270 -3280 3410 -3280 {
lab=OUT}
N 3270 -3220 3410 -3220 {
lab=z7}
N 3130 -3280 3270 -3280 {
lab=OUT}
N 3130 -3220 3270 -3220 {
lab=z7}
N 2570 -3280 3130 -3280 {
lab=OUT}
N 2570 -3220 3130 -3220 {
lab=z7}
N 3550 -3280 3700 -3280 {
lab=OUT}
N 3550 -3220 3700 -3220 {
lab=z7}
N 6770 -3280 6910 -3280 {
lab=OUT}
N 6770 -3220 6910 -3220 {
lab=z7}
N 6630 -3280 6770 -3280 {
lab=OUT}
N 6630 -3220 6770 -3220 {
lab=z7}
N 6490 -3280 6630 -3280 {
lab=OUT}
N 6490 -3220 6630 -3220 {
lab=z7}
N 5930 -3280 6490 -3280 {
lab=OUT}
N 5930 -3220 6490 -3220 {
lab=z7}
N 5640 -3280 5780 -3280 {
lab=OUT}
N 5640 -3220 5780 -3220 {
lab=z7}
N 5500 -3280 5640 -3280 {
lab=OUT}
N 5500 -3220 5640 -3220 {
lab=z7}
N 5360 -3280 5500 -3280 {
lab=OUT}
N 5360 -3220 5500 -3220 {
lab=z7}
N 4800 -3280 5360 -3280 {
lab=OUT}
N 4800 -3220 5360 -3220 {
lab=z7}
N 5780 -3280 5930 -3280 {
lab=OUT}
N 5780 -3220 5930 -3220 {
lab=z7}
N 4680 -3280 4800 -3280 {
lab=OUT}
N 4680 -3220 4800 -3220 {
lab=z7}
N 2430 -3280 2570 -3280 {
lab=OUT}
N 2430 -3220 2570 -3220 {
lab=z7}
N 9020 -3280 9160 -3280 {
lab=OUT}
N 9020 -3220 9160 -3220 {
lab=z7}
N 8880 -3280 9020 -3280 {
lab=OUT}
N 8880 -3220 9020 -3220 {
lab=z7}
N 8740 -3280 8880 -3280 {
lab=OUT}
N 8740 -3220 8880 -3220 {
lab=z7}
N 8180 -3280 8740 -3280 {
lab=OUT}
N 8180 -3220 8740 -3220 {
lab=z7}
N 7890 -3280 8030 -3280 {
lab=OUT}
N 7890 -3220 8030 -3220 {
lab=z7}
N 7750 -3280 7890 -3280 {
lab=OUT}
N 7750 -3220 7890 -3220 {
lab=z7}
N 7610 -3280 7750 -3280 {
lab=OUT}
N 7610 -3220 7750 -3220 {
lab=z7}
N 7050 -3280 7610 -3280 {
lab=OUT}
N 7050 -3220 7610 -3220 {
lab=z7}
N 8030 -3280 8180 -3280 {
lab=OUT}
N 8030 -3220 8180 -3220 {
lab=z7}
N 11250 -3280 11390 -3280 {
lab=OUT}
N 11250 -3220 11390 -3220 {
lab=z7}
N 11110 -3280 11250 -3280 {
lab=OUT}
N 11110 -3220 11250 -3220 {
lab=z7}
N 10970 -3280 11110 -3280 {
lab=OUT}
N 10970 -3220 11110 -3220 {
lab=z7}
N 10410 -3280 10970 -3280 {
lab=OUT}
N 10410 -3220 10970 -3220 {
lab=z7}
N 10120 -3280 10260 -3280 {
lab=OUT}
N 10120 -3220 10260 -3220 {
lab=z7}
N 9980 -3280 10120 -3280 {
lab=OUT}
N 9980 -3220 10120 -3220 {
lab=z7}
N 9840 -3280 9980 -3280 {
lab=OUT}
N 9840 -3220 9980 -3220 {
lab=z7}
N 9280 -3280 9840 -3280 {
lab=OUT}
N 9280 -3220 9840 -3220 {
lab=z7}
N 10260 -3280 10410 -3280 {
lab=OUT}
N 10260 -3220 10410 -3220 {
lab=z7}
N 9160 -3280 9280 -3280 {
lab=OUT}
N 9160 -3220 9280 -3220 {
lab=z7}
N 13500 -3280 13640 -3280 {
lab=OUT}
N 13500 -3220 13640 -3220 {
lab=z7}
N 13360 -3280 13500 -3280 {
lab=OUT}
N 13360 -3220 13500 -3220 {
lab=z7}
N 13220 -3280 13360 -3280 {
lab=OUT}
N 13220 -3220 13360 -3220 {
lab=z7}
N 12660 -3280 13220 -3280 {
lab=OUT}
N 12660 -3220 13220 -3220 {
lab=z7}
N 12370 -3280 12510 -3280 {
lab=OUT}
N 12370 -3220 12510 -3220 {
lab=z7}
N 12230 -3280 12370 -3280 {
lab=OUT}
N 12230 -3220 12370 -3220 {
lab=z7}
N 12090 -3280 12230 -3280 {
lab=OUT}
N 12090 -3220 12230 -3220 {
lab=z7}
N 11530 -3280 12090 -3280 {
lab=OUT}
N 11530 -3220 12090 -3220 {
lab=z7}
N 12510 -3280 12660 -3280 {
lab=OUT}
N 12510 -3220 12660 -3220 {
lab=z7}
N 15730 -3280 15870 -3280 {
lab=OUT}
N 15730 -3220 15870 -3220 {
lab=z7}
N 15590 -3280 15730 -3280 {
lab=OUT}
N 15590 -3220 15730 -3220 {
lab=z7}
N 15450 -3280 15590 -3280 {
lab=OUT}
N 15450 -3220 15590 -3220 {
lab=z7}
N 14890 -3280 15450 -3280 {
lab=OUT}
N 14890 -3220 15450 -3220 {
lab=z7}
N 14600 -3280 14740 -3280 {
lab=OUT}
N 14600 -3220 14740 -3220 {
lab=z7}
N 14460 -3280 14600 -3280 {
lab=OUT}
N 14460 -3220 14600 -3220 {
lab=z7}
N 14320 -3280 14460 -3280 {
lab=OUT}
N 14320 -3220 14460 -3220 {
lab=z7}
N 13760 -3280 14320 -3280 {
lab=OUT}
N 13760 -3220 14320 -3220 {
lab=z7}
N 14740 -3280 14890 -3280 {
lab=OUT}
N 14740 -3220 14890 -3220 {
lab=z7}
N 13640 -3280 13760 -3280 {
lab=OUT}
N 13640 -3220 13760 -3220 {
lab=z7}
N 11390 -3280 11530 -3280 {
lab=OUT}
N 11390 -3220 11530 -3220 {
lab=z7}
N 6910 -3280 7050 -3280 {
lab=OUT}
N 6910 -3220 7050 -3220 {
lab=z7}
N -1960 -3280 -1910 -3280 {
lab=OUT}
N 6980 -3040 7050 -3040 {
lab=OUT}
N 11440 -2820 11530 -2820 {
lab=OUT}
N 13660 -2570 13760 -2570 {
lab=OUT}
N 14800 -2330 14890 -2330 {
lab=OUT}
N 15390 -2090 15450 -2090 {
lab=OUT}
N 15630 -1860 15730 -1860 {
lab=OUT}
N 15790 -1630 15870 -1630 {
lab=OUT}
N 15870 -3220 15870 -3180 {
lab=z7}
N 15870 -2980 15870 -2940 {
lab=z6}
N 15870 -2760 15870 -2710 {
lab=z5}
N 15870 -2510 15870 -2460 {
lab=z4}
N 15870 -2270 15870 -2220 {
lab=z3}
N 15870 -2030 15870 -1990 {
lab=z2}
N 15870 -1800 15870 -1760 {
lab=z1}
N 15870 -1570 15870 -1530 {
lab=z0}
C {/foss/designs/SAR-ADC-using-Sky130-PDK/xschem/switch.sym} 8890 -750 0 0 {name=x1}
C {/foss/designs/SAR-ADC-using-Sky130-PDK/xschem/switch.sym} 8650 -750 0 0 {name=x2}
C {/foss/designs/SAR-ADC-using-Sky130-PDK/xschem/switch.sym} 8410 -750 0 0 {name=x3}
C {/foss/designs/SAR-ADC-using-Sky130-PDK/xschem/switch.sym} 8170 -750 0 0 {name=x4}
C {/foss/designs/SAR-ADC-using-Sky130-PDK/xschem/switch.sym} 7930 -750 0 0 {name=x5}
C {/foss/designs/SAR-ADC-using-Sky130-PDK/xschem/switch.sym} 7690 -750 0 0 {name=x6}
C {/foss/designs/SAR-ADC-using-Sky130-PDK/xschem/switch.sym} 7450 -750 0 0 {name=x7}
C {/foss/designs/SAR-ADC-using-Sky130-PDK/xschem/switch.sym} 7210 -750 0 0 {name=x8}
C {ipin.sym} 8790 -810 0 0 {name=b0 lab=b0}
C {ipin.sym} 8550 -810 0 0 {name=b1 lab=b1}
C {ipin.sym} 8310 -810 0 0 {name=b2 lab=b2
}
C {ipin.sym} 8070 -810 0 0 {name=b3 lab=b3}
C {ipin.sym} 7830 -810 0 0 {name=b4 lab=b4
}
C {ipin.sym} 7590 -810 0 0 {name=b5 lab=b5}
C {ipin.sym} 7350 -810 0 0 {name=b6 lab=b6}
C {ipin.sym} 7110 -810 0 0 {name=b7 lab=b7}
C {vdd.sym} 9030 -610 0 0 {name=l6 lab=VDD}
C {vdd.sym} 9030 -550 0 0 {name=l1 lab=GND}
C {ipin.sym} 7110 -710 0 0 {name=b8 lab=VDD}
C {ipin.sym} 7110 -690 0 0 {name=b9 lab=GND}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15870 -1600 0 1 {name=C2 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15730 -1830 0 1 {name=C1 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15870 -1830 0 1 {name=C9 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15870 -2060 0 0 {name=C3 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15730 -2060 0 0 {name=C4 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15590 -2060 0 0 {name=C5 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15450 -2060 0 0 {name=C6 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15870 -2300 0 0 {name=C7 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15730 -2300 0 0 {name=C8 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15590 -2300 0 0 {name=C10 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15450 -2300 0 0 {name=C11 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15310 -2300 0 0 {name=C12 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15170 -2300 0 0 {name=C13 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15030 -2300 0 0 {name=C14 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14890 -2300 0 0 {name=C15 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15870 -2540 0 0 {name=C16 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15730 -2540 0 0 {name=C17 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15590 -2540 0 0 {name=C18 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15450 -2540 0 0 {name=C19 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15310 -2540 0 0 {name=C20 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15170 -2540 0 0 {name=C21 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15030 -2540 0 0 {name=C22 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14890 -2540 0 0 {name=C23 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14740 -2540 0 0 {name=C24 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14600 -2540 0 0 {name=C25 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14460 -2540 0 0 {name=C26 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14320 -2540 0 0 {name=C27 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14180 -2540 0 0 {name=C28 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14040 -2540 0 0 {name=C29 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13900 -2540 0 0 {name=C30 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13760 -2540 0 0 {name=C31 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13640 -2790 0 0 {name=C32 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13500 -2790 0 0 {name=C33 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13360 -2790 0 0 {name=C34 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13220 -2790 0 0 {name=C35 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13080 -2790 0 0 {name=C36 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12940 -2790 0 0 {name=C37 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12800 -2790 0 0 {name=C38 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12660 -2790 0 0 {name=C39 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12510 -2790 0 0 {name=C40 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12370 -2790 0 0 {name=C41 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12230 -2790 0 0 {name=C42 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12090 -2790 0 0 {name=C43 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11950 -2790 0 0 {name=C44 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11810 -2790 0 0 {name=C45 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11670 -2790 0 0 {name=C46 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11530 -2790 0 0 {name=C47 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15870 -2790 0 0 {name=C48 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15730 -2790 0 0 {name=C49 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15590 -2790 0 0 {name=C50 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15450 -2790 0 0 {name=C51 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15310 -2790 0 0 {name=C52 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15170 -2790 0 0 {name=C53 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15030 -2790 0 0 {name=C54 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14890 -2790 0 0 {name=C55 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14740 -2790 0 0 {name=C56 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14600 -2790 0 0 {name=C57 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14460 -2790 0 0 {name=C58 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14320 -2790 0 0 {name=C59 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14180 -2790 0 0 {name=C60 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14040 -2790 0 0 {name=C61 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13900 -2790 0 0 {name=C62 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13760 -2790 0 0 {name=C63 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9160 -3010 0 0 {name=C64 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9020 -3010 0 0 {name=C65 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 8880 -3010 0 0 {name=C66 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 8740 -3010 0 0 {name=C67 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 8600 -3010 0 0 {name=C68 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 8460 -3010 0 0 {name=C69 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 8320 -3010 0 0 {name=C70 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 8180 -3010 0 0 {name=C71 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 8030 -3010 0 0 {name=C72 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 7890 -3010 0 0 {name=C73 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 7750 -3010 0 0 {name=C74 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 7610 -3010 0 0 {name=C75 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 7470 -3010 0 0 {name=C76 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 7330 -3010 0 0 {name=C77 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 7190 -3010 0 0 {name=C78 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 7050 -3010 0 0 {name=C79 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11390 -3010 0 0 {name=C80 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11250 -3010 0 0 {name=C81 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11110 -3010 0 0 {name=C82 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 10970 -3010 0 0 {name=C83 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 10830 -3010 0 0 {name=C84 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 10690 -3010 0 0 {name=C85 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 10550 -3010 0 0 {name=C86 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 10410 -3010 0 0 {name=C87 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 10260 -3010 0 0 {name=C88 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 10120 -3010 0 0 {name=C89 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9980 -3010 0 0 {name=C90 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9840 -3010 0 0 {name=C91 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9700 -3010 0 0 {name=C92 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9560 -3010 0 0 {name=C93 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9420 -3010 0 0 {name=C94 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9280 -3010 0 0 {name=C95 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13640 -3010 0 0 {name=C96 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13500 -3010 0 0 {name=C97 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13360 -3010 0 0 {name=C98 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13220 -3010 0 0 {name=C99 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13080 -3010 0 0 {name=C100 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12940 -3010 0 0 {name=C101 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12800 -3010 0 0 {name=C102 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12660 -3010 0 0 {name=C103 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12510 -3010 0 0 {name=C104 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12370 -3010 0 0 {name=C105 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12230 -3010 0 0 {name=C106 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12090 -3010 0 0 {name=C107 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11950 -3010 0 0 {name=C108 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11810 -3010 0 0 {name=C109 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11670 -3010 0 0 {name=C110 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11530 -3010 0 0 {name=C111 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15870 -3010 0 0 {name=C112 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15730 -3010 0 0 {name=C113 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15590 -3010 0 0 {name=C114 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15450 -3010 0 0 {name=C115 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15310 -3010 0 0 {name=C116 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15170 -3010 0 0 {name=C117 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15030 -3010 0 0 {name=C118 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14890 -3010 0 0 {name=C119 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14740 -3010 0 0 {name=C120 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14600 -3010 0 0 {name=C121 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14460 -3010 0 0 {name=C122 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14320 -3010 0 0 {name=C123 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14180 -3010 0 0 {name=C124 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14040 -3010 0 0 {name=C125 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13900 -3010 0 0 {name=C126 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13760 -3010 0 0 {name=C127 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 200 -3250 0 0 {name=C128 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 60 -3250 0 0 {name=C129 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} -80 -3250 0 0 {name=C130 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} -220 -3250 0 0 {name=C131 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} -360 -3250 0 0 {name=C132 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} -500 -3250 0 0 {name=C133 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} -640 -3250 0 0 {name=C134 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} -780 -3250 0 0 {name=C135 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} -930 -3250 0 0 {name=C136 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} -1070 -3250 0 0 {name=C137 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} -1210 -3250 0 0 {name=C138 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} -1350 -3250 0 0 {name=C139 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} -1490 -3250 0 0 {name=C140 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} -1630 -3250 0 0 {name=C141 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} -1770 -3250 0 0 {name=C142 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} -1910 -3250 0 0 {name=C143 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2430 -3250 0 0 {name=C144 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2290 -3250 0 0 {name=C145 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2150 -3250 0 0 {name=C146 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2010 -3250 0 0 {name=C147 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1870 -3250 0 0 {name=C148 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1730 -3250 0 0 {name=C149 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1590 -3250 0 0 {name=C150 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1450 -3250 0 0 {name=C151 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1300 -3250 0 0 {name=C152 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1160 -3250 0 0 {name=C153 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1020 -3250 0 0 {name=C154 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 880 -3250 0 0 {name=C155 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 740 -3250 0 0 {name=C156 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 600 -3250 0 0 {name=C157 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 460 -3250 0 0 {name=C158 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 320 -3250 0 0 {name=C159 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 4680 -3250 0 0 {name=C160 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 4540 -3250 0 0 {name=C161 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 4400 -3250 0 0 {name=C162 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 4260 -3250 0 0 {name=C163 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 4120 -3250 0 0 {name=C164 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 3980 -3250 0 0 {name=C165 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 3840 -3250 0 0 {name=C166 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 3700 -3250 0 0 {name=C167 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 3550 -3250 0 0 {name=C168 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 3410 -3250 0 0 {name=C169 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 3270 -3250 0 0 {name=C170 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 3130 -3250 0 0 {name=C171 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2990 -3250 0 0 {name=C172 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2850 -3250 0 0 {name=C173 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2710 -3250 0 0 {name=C174 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2570 -3250 0 0 {name=C175 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 6910 -3250 0 0 {name=C176 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 6770 -3250 0 0 {name=C177 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 6630 -3250 0 0 {name=C178 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 6490 -3250 0 0 {name=C179 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 6350 -3250 0 0 {name=C180 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 6210 -3250 0 0 {name=C181 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 6070 -3250 0 0 {name=C182 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 5930 -3250 0 0 {name=C183 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 5780 -3250 0 0 {name=C184 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 5640 -3250 0 0 {name=C185 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 5500 -3250 0 0 {name=C186 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 5360 -3250 0 0 {name=C187 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 5220 -3250 0 0 {name=C188 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 5080 -3250 0 0 {name=C189 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 4940 -3250 0 0 {name=C190 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 4800 -3250 0 0 {name=C191 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9160 -3250 0 0 {name=C192 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9020 -3250 0 0 {name=C193 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 8880 -3250 0 0 {name=C194 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 8740 -3250 0 0 {name=C195 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 8600 -3250 0 0 {name=C196 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 8460 -3250 0 0 {name=C197 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 8320 -3250 0 0 {name=C198 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 8180 -3250 0 0 {name=C199 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 8030 -3250 0 0 {name=C200 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 7890 -3250 0 0 {name=C201 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 7750 -3250 0 0 {name=C202 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 7610 -3250 0 0 {name=C203 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 7470 -3250 0 0 {name=C204 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 7330 -3250 0 0 {name=C205 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 7190 -3250 0 0 {name=C206 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 7050 -3250 0 0 {name=C207 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11390 -3250 0 0 {name=C208 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11250 -3250 0 0 {name=C209 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11110 -3250 0 0 {name=C210 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 10970 -3250 0 0 {name=C211 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 10830 -3250 0 0 {name=C212 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 10690 -3250 0 0 {name=C213 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 10550 -3250 0 0 {name=C214 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 10410 -3250 0 0 {name=C215 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 10260 -3250 0 0 {name=C216 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 10120 -3250 0 0 {name=C217 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9980 -3250 0 0 {name=C218 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9840 -3250 0 0 {name=C219 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9700 -3250 0 0 {name=C220 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9560 -3250 0 0 {name=C221 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9420 -3250 0 0 {name=C222 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 9280 -3250 0 0 {name=C223 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13640 -3250 0 0 {name=C224 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13500 -3250 0 0 {name=C225 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13360 -3250 0 0 {name=C226 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13220 -3250 0 0 {name=C227 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13080 -3250 0 0 {name=C228 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12940 -3250 0 0 {name=C229 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12800 -3250 0 0 {name=C230 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12660 -3250 0 0 {name=C231 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12510 -3250 0 0 {name=C232 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12370 -3250 0 0 {name=C233 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12230 -3250 0 0 {name=C234 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 12090 -3250 0 0 {name=C235 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11950 -3250 0 0 {name=C236 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11810 -3250 0 0 {name=C237 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11670 -3250 0 0 {name=C238 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 11530 -3250 0 0 {name=C239 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15870 -3250 0 0 {name=C240 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15730 -3250 0 0 {name=C241 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15590 -3250 0 0 {name=C242 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15450 -3250 0 0 {name=C243 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15310 -3250 0 0 {name=C244 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15170 -3250 0 0 {name=C245 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 15030 -3250 0 0 {name=C246 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14890 -3250 0 0 {name=C247 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14740 -3250 0 0 {name=C248 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14600 -3250 0 0 {name=C249 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14460 -3250 0 0 {name=C250 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14320 -3250 0 0 {name=C251 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14180 -3250 0 0 {name=C252 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 14040 -3250 0 0 {name=C253 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13900 -3250 0 0 {name=C254 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 13760 -3250 0 0 {name=C255 model=cap_mim_m3_2 W=22.7 L=2 MF=1 spiceprefix=X}
C {lab_wire.sym} 7190 -910 0 0 {name=p7 sig_type=std_logic lab=z7}
C {lab_wire.sym} 7430 -910 0 0 {name=p8 sig_type=std_logic lab=z6}
C {lab_wire.sym} 7670 -910 0 0 {name=p9 sig_type=std_logic lab=z5}
C {lab_wire.sym} 7910 -910 0 0 {name=p10 sig_type=std_logic lab=z4}
C {lab_wire.sym} 8150 -910 0 0 {name=p11 sig_type=std_logic lab=z3}
C {lab_wire.sym} 8390 -910 0 0 {name=p12 sig_type=std_logic lab=z2}
C {lab_wire.sym} 8630 -910 0 0 {name=p13 sig_type=std_logic lab=z1}
C {lab_wire.sym} 8870 -910 0 0 {name=p14 sig_type=std_logic lab=z0}
C {opin.sym} -1960 -3280 0 1 {name=b10 lab=OUT}
C {lab_pin.sym} 6980 -3040 0 0 {name=p1 sig_type=std_logic lab=OUT}
C {lab_pin.sym} 11440 -2820 0 0 {name=p2 sig_type=std_logic lab=OUT}
C {lab_pin.sym} 13660 -2570 0 0 {name=p3 sig_type=std_logic lab=OUT}
C {lab_pin.sym} 14800 -2330 0 0 {name=p4 sig_type=std_logic lab=OUT}
C {lab_pin.sym} 15390 -2090 0 0 {name=p5 sig_type=std_logic lab=OUT}
C {lab_pin.sym} 15630 -1860 0 0 {name=p6 sig_type=std_logic lab=OUT}
C {lab_pin.sym} 15790 -1630 0 0 {name=p15 sig_type=std_logic lab=OUT}
C {lab_pin.sym} 15870 -3180 0 1 {name=p16 sig_type=std_logic lab=z7}
C {lab_pin.sym} 15870 -2940 0 1 {name=p17 sig_type=std_logic lab=z6}
C {lab_pin.sym} 15870 -2710 0 1 {name=p18 sig_type=std_logic lab=z5}
C {lab_pin.sym} 15870 -2460 0 1 {name=p19 sig_type=std_logic lab=z4}
C {lab_pin.sym} 15870 -2220 0 1 {name=p20 sig_type=std_logic lab=z3}
C {lab_pin.sym} 15870 -1990 0 1 {name=p21 sig_type=std_logic lab=z2}
C {lab_pin.sym} 15870 -1760 0 1 {name=p22 sig_type=std_logic lab=z1}
C {lab_pin.sym} 15870 -1530 0 1 {name=p23 sig_type=std_logic lab=z0}
