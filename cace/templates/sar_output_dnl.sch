** sch_path: cace/templates/sar_output_dnl.sch
**.subckt sar_output_dnl
VVDD VDD GND DC CACE{VVDD}
VVGND VGND GND DC CACE{VVGND}
VVbias Vbias GND DC CACE{VVbias}
VVin Vin GND PWL(0 0 34u 0 34.000001u 0.00703125 68u 0.00703125 68.000001u 0.0140625 102u 0.0140625
+ 102.000001u 0.02109375 136u 0.02109375 136.000001u 0.028125 170u 0.028125 170.000001u 0.03515625 204u
+ 0.03515625 204.000001u 0.0421875 238u 0.0421875 238.000001u 0.04921875 272u 0.04921875 272.000001u 0.05625
+ 306u 0.05625 306.000001u 0.06328125 340u 0.06328125 340.000001u 0.0703125 374u 0.0703125 374.000001u
+ 0.07734375 408u 0.07734375 408.000001u 0.084375 442u 0.084375 442.000001u 0.09140625 476u 0.09140625
+ 476.000001u 0.0984375 510u 0.0984375 510.000001u 0.10546875 544u 0.10546875 544.000001u 0.1125 578u 0.1125
+ 578.000001u 0.11953125 612u 0.11953125 612.000001u 0.1265625 646u 0.1265625 646.000001u 0.13359375 680u
+ 0.13359375 680.000001u 0.140625 714u 0.140625 714.000001u 0.14765625 748u 0.14765625 748.000001u 0.1546875
+ 782u 0.1546875 782.000001u 0.16171875 816u 0.16171875 816.000001u 0.16875 850u 0.16875 850.000001u
+ 0.17578125 884u 0.17578125 884.000001u 0.1828125 918u 0.1828125 918.000001u 0.18984375 952u 0.18984375
+ 952.000001u 0.196875 986u 0.196875 986.000001u 0.20390625 1020u 0.20390625 1020.000001u 0.2109375 1054u
+ 0.2109375 1054.000001u 0.21796875 1088u 0.21796875 1088.000001u 0.225 1122u 0.225 1122.000001u 0.23203125
+ 1156u 0.23203125 1156.000001u 0.2390625 1190u 0.2390625 1190.000001u 0.24609375 1224u 0.24609375
+ 1224.000001u 0.253125 1258u 0.253125 1258.000001u 0.26015625 1292u 0.26015625 1292.000001u 0.2671875 1326u
+ 0.2671875 1326.000001u 0.27421875 1360u 0.27421875 1360.000001u 0.28125 1394u 0.28125 1394.000001u 0.28828125
+ 1428u 0.28828125 1428.000001u 0.2953125 1462u 0.2953125 1462.000001u 0.30234375 1496u 0.30234375
+ 1496.000001u 0.309375 1530u 0.309375 1530.000001u 0.31640625 1564u 0.31640625 1564.000001u 0.3234375 1598u
+ 0.3234375 1598.000001u 0.33046875 1632u 0.33046875 1632.000001u 0.3375 1666u 0.3375 1666.000001u 0.34453125
+ 1700u 0.34453125 1700.000001u 0.3515625 1734u 0.3515625 1734.000001u 0.35859375 1768u 0.35859375
+ 1768.000001u 0.365625 1802u 0.365625 1802.000001u 0.37265625 1836u 0.37265625 1836.000001u 0.3796875 1870u
+ 0.3796875 1870.000001u 0.38671875 1904u 0.38671875 1904.000001u 0.39375 1938u 0.39375 1938.000001u 0.40078125
+ 1972u 0.40078125 1972.000001u 0.4078125 2006u 0.4078125 2006.000001u 0.41484375 2040u 0.41484375
+ 2040.000001u 0.421875 2074u 0.421875 2074.000001u 0.42890625 2108u 0.42890625 2108.000001u 0.4359375 2142u
+ 0.4359375 2142.000001u 0.44296875 2176u 0.44296875 2176.000001u 0.45 2210u 0.45 2210.000001u 0.45703125 2244u
+ 0.45703125 2244.000001u 0.4640625 2278u 0.4640625 2278.000001u 0.47109375 2312u 0.47109375 2312.000001u
+ 0.478125 2346u 0.478125 2346.000001u 0.48515625 2380u 0.48515625 2380.000001u 0.4921875 2414u 0.4921875
+ 2414.000001u 0.49921875 2448u 0.49921875 2448.000001u 0.50625 2482u 0.50625 2482.000001u 0.51328125 2516u
+ 0.51328125 2516.000001u 0.5203125 2550u 0.5203125 2550.000001u 0.52734375 2584u 0.52734375 2584.000001u
+ 0.534375 2618u 0.534375 2618.000001u 0.54140625 2652u 0.54140625 2652.000001u 0.5484375 2686u 0.5484375
+ 2686.000001u 0.55546875 2720u 0.55546875 2720.000001u 0.5625 2754u 0.5625 2754.000001u 0.56953125 2788u
+ 0.56953125 2788.000001u 0.5765625 2822u 0.5765625 2822.000001u 0.58359375 2856u 0.58359375 2856.000001u
+ 0.590625 2890u 0.590625 2890.000001u 0.59765625 2924u 0.59765625 2924.000001u 0.6046875 2958u 0.6046875
+ 2958.000001u 0.61171875 2992u 0.61171875 2992.000001u 0.61875 3026u 0.61875 3026.000001u 0.62578125 3060u
+ 0.62578125 3060.000001u 0.6328125 3094u 0.6328125 3094.000001u 0.63984375 3128u 0.63984375 3128.000001u
+ 0.646875 3162u 0.646875 3162.000001u 0.65390625 3196u 0.65390625 3196.000001u 0.6609375 3230u 0.6609375
+ 3230.000001u 0.66796875 3264u 0.66796875 3264.000001u 0.675 3298u 0.675 3298.000001u 0.68203125 3332u 0.68203125
+ 3332.000001u 0.6890625 3366u 0.6890625 3366.000001u 0.69609375 3400u 0.69609375 3400.000001u 0.703125 3434u
+ 0.703125 3434.000001u 0.71015625 3468u 0.71015625 3468.000001u 0.7171875 3502u 0.7171875 3502.000001u
+ 0.72421875 3536u 0.72421875 3536.000001u 0.73125 3570u 0.73125 3570.000001u 0.73828125 3604u 0.73828125
+ 3604.000001u 0.7453125 3638u 0.7453125 3638.000001u 0.75234375 3672u 0.75234375 3672.000001u 0.759375 3706u
+ 0.759375 3706.000001u 0.76640625 3740u 0.76640625 3740.000001u 0.7734375 3774u 0.7734375 3774.000001u
+ 0.78046875 3808u 0.78046875 3808.000001u 0.7875 3842u 0.7875 3842.000001u 0.79453125 3876u 0.79453125
+ 3876.000001u 0.8015625 3910u 0.8015625 3910.000001u 0.80859375 3944u 0.80859375 3944.000001u 0.815625 3978u
+ 0.815625 3978.000001u 0.82265625 4012u 0.82265625 4012.000001u 0.8296875 4046u 0.8296875 4046.000001u
+ 0.83671875 4080u 0.83671875 4080.000001u 0.84375 4114u 0.84375 4114.000001u 0.85078125 4148u 0.85078125
+ 4148.000001u 0.8578125 4182u 0.8578125 4182.000001u 0.86484375 4216u 0.86484375 4216.000001u 0.871875 4250u
+ 0.871875 4250.000001u 0.87890625 4284u 0.87890625 4284.000001u 0.8859375 4318u 0.8859375 4318.000001u
+ 0.89296875 4352u 0.89296875 4352.000001u 0.9 4386u 0.9 4386.000001u 0.90703125 4420u 0.90703125 4420.000001u
+ 0.9140625 4454u 0.9140625 4454.000001u 0.92109375 4488u 0.92109375 4488.000001u 0.928125 4522u 0.928125
+ 4522.000001u 0.93515625 4556u 0.93515625 4556.000001u 0.9421875 4590u 0.9421875 4590.000001u 0.94921875 4624u
+ 0.94921875 4624.000001u 0.95625 4658u 0.95625 4658.000001u 0.96328125 4692u 0.96328125 4692.000001u 0.9703125
+ 4726u 0.9703125 4726.000001u 0.97734375 4760u 0.97734375 4760.000001u 0.984375 4794u 0.984375
+ 4794.000001u 0.99140625 4828u 0.99140625 4828.000001u 0.9984375 4862u 0.9984375 4862.000001u 1.00546875 4896u
+ 1.00546875 4896.000001u 1.0125 4930u 1.0125 4930.000001u 1.01953125 4964u 1.01953125 4964.000001u 1.0265625
+ 4998u 1.0265625 4998.000001u 1.03359375 5032u 1.03359375 5032.000001u 1.040625 5066u 1.040625
+ 5066.000001u 1.04765625 5100u 1.04765625 5100.000001u 1.0546875 5134u 1.0546875 5134.000001u 1.06171875 5168u
+ 1.06171875 5168.000001u 1.06875 5202u 1.06875 5202.000001u 1.07578125 5236u 1.07578125 5236.000001u 1.0828125
+ 5270u 1.0828125 5270.000001u 1.08984375 5304u 1.08984375 5304.000001u 1.096875 5338u 1.096875
+ 5338.000001u 1.10390625 5372u 1.10390625 5372.000001u 1.1109375 5406u 1.1109375 5406.000001u 1.11796875 5440u
+ 1.11796875 5440.000001u 1.125 5474u 1.125 5474.000001u 1.13203125 5508u 1.13203125 5508.000001u 1.1390625
+ 5542u 1.1390625 5542.000001u 1.14609375 5576u 1.14609375 5576.000001u 1.153125 5610u 1.153125
+ 5610.000001u 1.16015625 5644u 1.16015625 5644.000001u 1.1671875 5678u 1.1671875 5678.000001u 1.17421875 5712u
+ 1.17421875 5712.000001u 1.18125 5746u 1.18125 5746.000001u 1.18828125 5780u 1.18828125 5780.000001u 1.1953125
+ 5814u 1.1953125 5814.000001u 1.20234375 5848u 1.20234375 5848.000001u 1.209375 5882u 1.209375
+ 5882.000001u 1.21640625 5916u 1.21640625 5916.000001u 1.2234375 5950u 1.2234375 5950.000001u 1.23046875 5984u
+ 1.23046875 5984.000001u 1.2375 6018u 1.2375 6018.000001u 1.24453125 6052u 1.24453125 6052.000001u 1.2515625
+ 6086u 1.2515625 6086.000001u 1.25859375 6120u 1.25859375 6120.000001u 1.265625 6154u 1.265625
+ 6154.000001u 1.27265625 6188u 1.27265625 6188.000001u 1.2796875 6222u 1.2796875 6222.000001u 1.28671875 6256u
+ 1.28671875 6256.000001u 1.29375 6290u 1.29375 6290.000001u 1.30078125 6324u 1.30078125 6324.000001u 1.3078125
+ 6358u 1.3078125 6358.000001u 1.31484375 6392u 1.31484375 6392.000001u 1.321875 6426u 1.321875
+ 6426.000001u 1.32890625 6460u 1.32890625 6460.000001u 1.3359375 6494u 1.3359375 6494.000001u 1.34296875 6528u
+ 1.34296875 6528.000001u 1.35 6562u 1.35 6562.000001u 1.35703125 6596u 1.35703125 6596.000001u 1.3640625 6630u
+ 1.3640625 6630.000001u 1.37109375 6664u 1.37109375 6664.000001u 1.378125 6698u 1.378125 6698.000001u
+ 1.38515625 6732u 1.38515625 6732.000001u 1.3921875 6766u 1.3921875 6766.000001u 1.39921875 6800u 1.39921875
+ 6800.000001u 1.40625 6834u 1.40625 6834.000001u 1.41328125 6868u 1.41328125 6868.000001u 1.4203125 6902u
+ 1.4203125 6902.000001u 1.42734375 6936u 1.42734375 6936.000001u 1.434375 6970u 1.434375 6970.000001u
+ 1.44140625 7004u 1.44140625 7004.000001u 1.4484375 7038u 1.4484375 7038.000001u 1.45546875 7072u 1.45546875
+ 7072.000001u 1.4625 7106u 1.4625 7106.000001u 1.46953125 7140u 1.46953125 7140.000001u 1.4765625 7174u 1.4765625
+ 7174.000001u 1.48359375 7208u 1.48359375 7208.000001u 1.490625 7242u 1.490625 7242.000001u 1.49765625 7276u
+ 1.49765625 7276.000001u 1.5046875 7310u 1.5046875 7310.000001u 1.51171875 7344u 1.51171875 7344.000001u
+ 1.51875 7378u 1.51875 7378.000001u 1.52578125 7412u 1.52578125 7412.000001u 1.5328125 7446u 1.5328125
+ 7446.000001u 1.53984375 7480u 1.53984375 7480.000001u 1.546875 7514u 1.546875 7514.000001u 1.55390625 7548u
+ 1.55390625 7548.000001u 1.5609375 7582u 1.5609375 7582.000001u 1.56796875 7616u 1.56796875 7616.000001u 1.575
+ 7650u 1.575 7650.000001u 1.58203125 7684u 1.58203125 7684.000001u 1.5890625 7718u 1.5890625 7718.000001u
+ 1.59609375 7752u 1.59609375 7752.000001u 1.603125 7786u 1.603125 7786.000001u 1.61015625 7820u 1.61015625
+ 7820.000001u 1.6171875 7854u 1.6171875 7854.000001u 1.62421875 7888u 1.62421875 7888.000001u 1.63125 7922u
+ 1.63125 7922.000001u 1.63828125 7956u 1.63828125 7956.000001u 1.6453125 7990u 1.6453125 7990.000001u
+ 1.65234375 8024u 1.65234375 8024.000001u 1.659375 8058u 1.659375 8058.000001u 1.66640625 8092u 1.66640625
+ 8092.000001u 1.6734375 8126u 1.6734375 8126.000001u 1.68046875 8160u 1.68046875 8160.000001u 1.6875 8194u 1.6875
+ 8194.000001u 1.69453125 8228u 1.69453125 8228.000001u 1.7015625 8262u 1.7015625 8262.000001u 1.70859375 8296u
+ 1.70859375 8296.000001u 1.715625 8330u 1.715625 8330.000001u 1.72265625 8364u 1.72265625 8364.000001u
+ 1.7296875 8398u 1.7296875 8398.000001u 1.73671875 8432u 1.73671875 8432.000001u 1.74375 8466u 1.74375
+ 8466.000001u 1.75078125 8500u 1.75078125 8500.000001u 1.7578125 8534u 1.7578125 8534.000001u 1.76484375 8568u
+ 1.76484375 8568.000001u 1.771875 8602u 1.771875 8602.000001u 1.77890625 8636u 1.77890625 8636.000001u
+ 1.7859375 8670u 1.7859375 8670.000001u 1.79296875 8704u 1.79296875 8704.000001u 1.8 8738u 1.8)
R1 net1 GND 0.01 m=1
Rout GND Q7 CACE{Rout} m=1
Rout1 GND Q6 CACE{Rout} m=1
Rout2 GND Q5 CACE{Rout} m=1
Rout3 GND Q4 CACE{Rout} m=1
Rout4 GND Q3 CACE{Rout} m=1
Rout5 GND Q2 CACE{Rout} m=1
Rout6 GND Q1 CACE{Rout} m=1
Rout7 GND Q0 CACE{Rout} m=1
x1 VDD Vin Q0 Vbias EN Q1 CLK Q2 Q3 Q4 Q5 Q6 Q7 VGND SAR-ADC-using-Sky130-PDK
VEN EN net1 PULSE(1.8 0 0 100ps 100ps 0.25u 0)
VCLK CLK GND PULSE(1.8 0 0 100p 100p 0.25u 0.5u)
**** begin user architecture code

* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the DAC.  Include both current through vdd and VREFH

.include CACE{DUT_path}
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_hvl/spice/sky130_fd_sc_hvl.spice

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1




.control
set wr_singlescale
set timepoints = 34u

  tran 1u 8738u 0 1u uic
  wrdata CACE{simpath}/CACE{filename}_CACE{N}.data V(Vin) V(Q7) V(Q6) V(Q5) V(Q4) V(Q3) V(Q2) V(Q1) V(Q0)

end

quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
