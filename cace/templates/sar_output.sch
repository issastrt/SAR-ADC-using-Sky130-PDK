** sch_path: cace/templates/sar_output.sch
**.subckt sar_output
VVDD VDD GND DC CACE{VVDD}
VVGND VGND GND DC CACE{VVGND}
VVbias Vbias GND DC CACE{VVbias}
VVin Vin GND DC CACE{VVin}
R1 net1 GND 0.01 m=1
Rout GND Q7 CACE{Rout} m=1
Rout1 GND Q6 CACE{Rout} m=1
Rout2 GND Q5 CACE{Rout} m=1
Rout3 GND Q4 CACE{Rout} m=1
Rout4 GND Q3 CACE{Rout} m=1
Rout5 GND Q2 CACE{Rout} m=1
Rout6 GND Q1 CACE{Rout} m=1
Rout7 GND Q0 CACE{Rout} m=1
x1 VDD Vin Q0 Vbias EN Q1 CLK Q2 Q3 Q4 Q5 Q6 Q7 VGND SAR-ADC-using-Sky130-PDK
VCLK CLK GND PULSE(1.8 0 0 100p 100p 0.25u 0.5u)
VEN EN net1 PULSE(1.8 0 0 100ps 100ps 0.25u 0)
**** begin user architecture code

* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the DAC.  Include both current through vdd and VREFH

.include CACE{DUT_path}
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_hvl/spice/sky130_fd_sc_hvl.spice

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1




.control
tran 0.5u 8.5u uic
set wr_singlescale
set timepoints=34u
wrdata CACE{simpath}/CACE{filename}_CACE{N}.data V(Vin) V(Q7) V(Q6) V(Q5) V(Q4) V(Q3) V(Q2) V(Q1) V(Q0)
quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
