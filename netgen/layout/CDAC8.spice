* NGSPICE file created from CDAC8.ext - technology: sky130A

.subckt sky130_fd_pr__pfet_g5v0d10v5_CY7YBN a_n130_n144# a_72_n144# w_n330_n441# a_n72_n241#
X0 a_72_n144# a_n72_n241# a_n130_n144# w_n330_n441# sky130_fd_pr__pfet_g5v0d10v5 ad=0.4176 pd=3.46 as=0.4176 ps=3.46 w=1.44 l=0.72
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5_3Y2F6P a_n202_n144# a_n144_n232# a_144_n144#
+ a_n336_n366#
X0 a_144_n144# a_n144_n232# a_n202_n144# a_n336_n366# sky130_fd_pr__nfet_g5v0d10v5 ad=0.4176 pd=3.46 as=0.4176 ps=3.46 w=1.44 l=1.44
.ends

.subckt switch Z A B Vref VDD GND
XXM1 B Z VDD m1_1636_n741# sky130_fd_pr__pfet_g5v0d10v5_CY7YBN
XXM2 Z Vref B GND sky130_fd_pr__nfet_g5v0d10v5_3Y2F6P
XXM3 Z A VDD Vref sky130_fd_pr__pfet_g5v0d10v5_CY7YBN
XXM4 A m1_1636_n741# Z GND sky130_fd_pr__nfet_g5v0d10v5_3Y2F6P
XXM5 VDD m1_1636_n741# VDD Vref sky130_fd_pr__pfet_g5v0d10v5_CY7YBN
XXM6 GND Vref m1_1636_n741# GND sky130_fd_pr__nfet_g5v0d10v5_3Y2F6P
.ends

.subckt sky130_fd_pr__cap_mim_m3_2_XAJUMH m4_n2619_n280# c2_n2539_n200#
X0 c2_n2539_n200# m4_n2619_n280# sky130_fd_pr__cap_mim_m3_2 l=2 w=22.7
.ends

.subckt CDAC8 GND VDD OUT b0 b1 b2 b3 b4 b5 b6 b7
Xswitch_0 switch_0/Z GND VDD b2 VDD GND switch
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_28 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_39 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_17 switch_2/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_193 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_182 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_171 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_160 switch_0/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xswitch_1 switch_1/Z GND VDD b0 VDD GND switch
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_29 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_18 switch_0/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_194 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_183 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_150 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_161 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_172 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xswitch_2 switch_2/Z GND VDD b1 VDD GND switch
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_19 switch_0/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_195 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_184 switch_5/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_140 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_162 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_173 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_196 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_185 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_130 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_141 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_152 switch_0/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_163 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_174 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_120 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_197 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_186 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_131 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_142 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_164 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_153 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_175 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xswitch_5 switch_5/Z GND VDD b3 VDD GND switch
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_121 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_198 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_187 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_110 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_132 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_143 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_165 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_154 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_176 switch_5/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xswitch_6 switch_6/Z GND VDD b5 VDD GND switch
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_122 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_199 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_188 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_177 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_133 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_100 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_144 switch_2/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_166 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_155 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_111 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xswitch_7 switch_7/Z GND VDD b4 VDD GND switch
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_123 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_189 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_178 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_134 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_145 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_101 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_112 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_167 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_156 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xswitch_8 switch_8/Z GND VDD b7 VDD GND switch
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_124 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_113 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_179 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_135 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_102 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_146 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_168 switch_5/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_157 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xswitch_9 switch_9/Z GND VDD b6 VDD GND switch
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_0 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_125 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_114 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_169 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_103 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_147 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_158 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_1 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_126 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_115 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_104 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_137 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_148 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_159 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_2 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_127 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_116 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_105 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_138 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_149 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_3 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_128 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_117 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_106 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_139 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_4 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_118 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_129 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_107 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_5 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_119 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_108 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_6 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_109 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_7 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_8 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_9 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_250 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_251 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_240 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_252 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_241 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_230 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_253 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_242 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_231 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_220 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_90 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_254 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_243 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_232 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_221 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_210 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_80 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_91 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_255 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_244 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_233 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_222 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_211 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_200 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_70 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_81 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_92 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_256 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_245 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_234 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_223 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_212 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_201 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_71 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_82 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_93 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_60 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_246 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_235 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_224 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_213 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_202 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_50 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_72 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_83 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_94 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_61 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_247 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_225 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_236 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_214 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_203 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_51 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_73 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_40 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_84 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_95 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_62 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_248 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_226 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_237 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_215 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_204 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_30 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_52 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_74 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_41 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_96 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_85 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_63 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_249 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_227 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_238 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_216 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_205 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_20 switch_5/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_31 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_53 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_75 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_42 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_64 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_86 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_97 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_228 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_239 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_217 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_206 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_32 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_54 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_43 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_10 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_76 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_65 switch_1/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_98 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_87 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_21 switch_5/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_229 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_218 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_207 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_44 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_11 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_55 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_77 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_22 switch_5/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_99 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_66 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_33 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_88 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_219 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_208 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_45 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_12 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_78 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_23 switch_5/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_56 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_67 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_34 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_89 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_209 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_46 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_13 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_79 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_24 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_57 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_68 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_35 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_47 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_14 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_69 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_25 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_58 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_36 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_190 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_15 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_48 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_26 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_59 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_37 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_191 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_180 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_49 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_27 switch_7/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_38 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_16 switch_6/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_192 switch_5/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_181 switch_9/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
Xsky130_fd_pr__cap_mim_m3_2_XAJUMH_170 switch_8/Z OUT sky130_fd_pr__cap_mim_m3_2_XAJUMH
.ends
